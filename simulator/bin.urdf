Commit message: Bin dropping

File: simulator/bin.urdf (robot description, URDF)
Before this commit: robot bin, 1 links, 0 joints
Links:
- link base_link: mass None -> 0
